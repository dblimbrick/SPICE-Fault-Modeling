* SPICE netlist generated by Yosys 0.9 (git sha1 1979e0b)

.SUBCKT c17 G1 G2 G3 G4 G5 VPWR VGND out1 out2
X0 1 G3 G4 VPWR VPWR VGND VGND sky130_fd_sc_hd__nand2_1
X1 out1 G1 G3 G2 1 VPWR VPWR VGND VGND sky130_fd_sc_hd__a22o_1
X2 out2 G2 G5 1 VPWR VPWR VGND VGND sky130_fd_sc_hd__o21a_1
.ENDS c17

************************
* end of SPICE netlist *
************************
